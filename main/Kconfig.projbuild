## main/Kconfig.projbuild
```kconfig
menu "WiFi Credentials"
    config WIFI_SSID
        string "SSID"
    config WIFI_PASSWORD
        string "Password"
endmenu
```
